# Keil uVision project wirSwitch.uvproj, settings and files
target switch (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: wirSwitch +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 Uart1.c Uart.h main.c
